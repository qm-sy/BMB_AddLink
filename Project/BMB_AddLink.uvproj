# Keil uVision project BMB_AddLink.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408S STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: BMB_AddLink +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\BSP\Inc;..\Core\Inc;..\Drivers;..\Middlewares;..\Emembed\Inc;..\SYSTEM\Inc
  group Source Group 1
    ./: STARTUP.A51
  group Core
    ../Core/Src/: eeprom.c gpio.c main.c uart.c tim.c
  group BSP
    ../BSP/Src/: level.c eeprom_crl.c
  group SYSTEM
    ../SYSTEM/Src/: delay.c
